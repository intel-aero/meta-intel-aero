RDEPENDS_${PN} += "glibc-gconv-utf-16"
