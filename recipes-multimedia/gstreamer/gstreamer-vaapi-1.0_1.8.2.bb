require gstreamer-vaapi.inc

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"

SRC_URI[md5sum] = "5683e0e950160f6a4b5bcd47176baad0"
SRC_URI[sha256sum] = "5479e86f593d80c00bbd4a43b16b2027cb935412a2bb22c9ba4ac085627a9229"
