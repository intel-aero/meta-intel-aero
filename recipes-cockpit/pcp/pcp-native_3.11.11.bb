require pcp.inc
inherit native

DEPENDS += "flex-native bison-native"

export PCP_DIR = "${STAGING_DIR_NATIVE}"

