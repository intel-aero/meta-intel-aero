FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-intel-aero-rename-PWRF-to-PBTN.patch \
		file://0002-intel-aero-shutdown-to-handle-LED-toggling.patch \
		"
