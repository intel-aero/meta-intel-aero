DESCRIPTION = "Intel Aero Image with test and debug capabilities"

require intel-aero-image.bb
IMAGE_INSTALL += 'python-pexpect'
